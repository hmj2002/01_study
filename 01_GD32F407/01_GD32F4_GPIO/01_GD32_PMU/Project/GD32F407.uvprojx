# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Hardware;..\Firmware\GD32F4xx_standard_peripheral\Source;..\Library\usart;..\Library\EXTI;..\Library\TIMER;..\Library\RTC;..\Library\I2C;..\Library\ADC;..\Hardware\OLED_SPI;..\Library\SPI;..\Library\CAN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c systick.c main.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_pmu.c gd32f4xx_rtc.c gd32f4xx_wwdgt.c gd32f4xx_fwdgt.c gd32f4xx_i2c.c gd32f4xx_adc.c gd32f4xx_spi.c gd32f4xx_can.c gd32f4xx_dbg.c
  group Hardware
    ../Hardware/: gpio_cfg.h bsp_leds.c bsp_leds.h bsp_keys.c bsp_keys.h bsp_DHT11.c bsp_DHT11.h bsp_MatrixKeys.c bsp_MatrixKeys.h bsp_PCF8563.c bsp_PCF8563.h bsp_Nixie.c bsp_Nixie.h bsp_NTC.c bsp_NTC.h spi_flash.c spi_flash.h
    ../Hardware/OLED_SPI/: oled.c
  group Doc
    ../Doc/: readme.txt
  group Library
    ../Library/usart/: USART0.c USART0.h USART2.c USART2.h
    ../Library/EXTI/: EXTI.c EXTI.h EXTI_config.h
    ../Library/TIMER/: TIMER.c TIMER.h TIMER_config.h
    ../Library/RTC/: rtc_time.c rtc_time.h
    ../Library/I2C/: I2C0_soft.c I2C0_soft.h I2C0_hard.c I2C0_hard.h
    ../Library/ADC/: ADC.c ADC.h
    ../Library/SPI/: SPI0_soft.c SPI0_soft.h SPI0_hard.c SPI0_hard.h
    ../Library/CAN/: can.c can.h
